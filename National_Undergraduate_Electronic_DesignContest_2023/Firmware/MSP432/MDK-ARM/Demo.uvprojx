# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --diag_suppress 1296 --diag_suppress=1
  c include: ..\Drivers\third_party\CMSIS\Include;..\Drivers;..\User\Inc;..\Core\Inc;..\DSP_Lib\CMSIS\Include;..\Hardware\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../Source/: startup_msp432p401r_uvision.s system_msp432p401r.c
  group DriverLib
    ../Drivers/ti/devices/msp432p4xx/driverlib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c flash_a.c fpu.c gpio.c i2c.c interrupt.c lcd_f.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c sysctl_a.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group DSP_Lib
    ../DSP_Lib/CMSIS/DSP_Lib/lib/keil/m4f/: arm_cortexM4lf_math.a
  group Core
    ../Core/Src/: sys.c delay.c usart.c tim.c
  group User
    ../User/Src/: main.c Key.c Led.c Cap_Int.c Adc_in.c windowfunction.c my_math.c UART_HMI.c IO_control.c
  group Hardware
    ../Hardware/Src/: eeprom.c AD985x.c ADF4351.c TLV5618.c
software components: CMSIS:CORE 5.5.0
